# Keil uVision project 26.uvprojx, settings and files
target 26 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 26 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .;..\Core\Inc;..\App\Inc;..\BSP\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;.cmsis\include;RTE\_26
  asm include: ../Core/Inc;../App/Inc;../BSP/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Application/MechanicalArm/Tools
    ../tools/: arm_pc_serial.py puzzle1_uart_test.py
  group Application/MechanicalArm/Documentation
    ../docs/: 机械臂驱动移植与修改指南.md 第一问逆解与自动拼图说明.md A4六点巡边校准说明.md
  group Application/MechanicalArm/BSP/Include
    ../BSP/Inc/: bsp_servo_pwm.h bsp_uart_common.h bsp_uart_dma.h bsp_debug_uart_dma.h bsp_magnet.h bsp_puzzle_indicator.h bsp_safety_io.h
  group Application/MechanicalArm/BSP/Source
    ../BSP/Src/: bsp_servo_pwm.c bsp_uart_dma.c bsp_debug_uart_dma.c bsp_magnet.c bsp_puzzle_indicator.c bsp_safety_io.c
  group Application/MechanicalArm/App/Include
    ../App/Inc/: arm_config.h arm_types.h arm_app.h arm_servo.h arm_motion.h arm_protocol.h arm_puzzle_protocol.h arm_kinematics.h arm_calibration.h arm_puzzle.h arm_comm.h arm_debug_cli.h arm_safety.h
  group Application/MechanicalArm/App/Source
    ../App/Src/: arm_app.c arm_servo.c arm_motion.c arm_protocol.c arm_puzzle_protocol.c arm_kinematics.c arm_calibration.c arm_puzzle.c arm_comm.c arm_debug_cli.c arm_safety.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
software components: CMSIS:CORE 4.3.0
